# IAR project VirtualCOMPort.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32L152xB ST STM32L152xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; USE_STM32L152_EVAL; ENABLE_USB; SYSCLK_FREQ_HSI_32MHz
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\platform\STM32L1XX\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx; ..\..\..\platform\STM32L1XX\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\platform\STM32L1XX\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\platform\STM32L1XX\Libraries\SDK_Eval_STM32L\inc; ..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BlueNRG_VCOM_1_3.hex
  ILINK.IlinkOutputFile: VirtualCOMPort.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../src/: system_stm32l1xx.c
  group EWARM
    ../../../platform/STM32L1XX/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32L1xx/startup/iar/: startup_stm32l1xx_md.s
  group Platforms_Layers
    ../../../platform/STM32L1XX/Libraries/SDK_Eval_STM32L/src/: SDK_EVAL_Config.c SDK_EVAL_EEPROM.c SDK_EVAL_Io.c SDK_EVAL_Spi_Driver.c
  group STM32L1xx_StdPeriph_Driver
    ../../../platform/STM32L1XX/Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_systick.c stm32l1xx_usart.c
  group USB-FS-Device_Driver
    ../../../platform/STM32L1XX/Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group User
    ../src/: BlueNRG_VCOM_main.c cmd.c hci.c hw_config.c stm32l1xx_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
    ../../../platform/STM32L1XX/: clock.c
  group utils
    ../../../Bluetooth LE/SimpleBlueNRG_HCI/utils/: gp_timer.c
