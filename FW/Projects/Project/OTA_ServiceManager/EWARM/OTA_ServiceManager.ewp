# IAR project OTA_ServiceManager.ewp, settings and files
configuration App (ARM)
  General.OGChipSelectEditMenu: STM32L151xB ST STM32L151xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; SYSCLK_MSI; ST_OTA_BTL; ST_OTA_BASIC_APPLICATION_FIXED_BASE_ADDRESS
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Bluetooth LE\SimpleBlueNRG_HCI; ..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes; ..\..\..\platform\STM32L1XX; ..\..\..\platform\STM32L1XX\Libraries; ..\..\..\platform\STM32L1XX\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx; ..\..\..\platform\STM32L1XX\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\platform\STM32L1XX\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\platform\STM32L1XX\Libraries\I2C\inc; ..\..\..\platform\STM32L1XX\Libraries\LIS3DH\inc; ..\..\..\platform\STM32L1XX\Libraries\STLM75\inc; ..\..\..\platform\STM32L1XX\Libraries\HTS221\inc; ..\..\..\platform\STM32L1XX\Libraries\LPS25H\inc; ..\..\..\platform\STM32L1XX\Libraries\SDK_Eval_STM32L\inc; ..\..\..\Bluetooth LE\BlueNRG_OTA\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OTA_ServiceManager_App.hex
  ILINK.IlinkOutputFile: OTA_ServiceManager_App.out
  ILINK.IlinkConfigDefines: ST_OTA_BTL=1
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group blestack/hci
    ../../../Bluetooth LE/SimpleBlueNRG_HCI/hci/: hci.c
  group blestack/hci/controller
    ../../../Bluetooth LE/SimpleBlueNRG_HCI/hci/controller/: bluenrg_hci.c
  group blestack/includes
    ../../../Bluetooth LE/SimpleBlueNRG_HCI/includes/: ble_status.h bluenrg_hci.h bluenrg_hci_internal.h clock.h compiler.h gap.h gatt_server.h gp_timer.h hal.h hal_types.h hci.h hci_internal.h link_layer.h list.h osal.h sm.h
  group blestack/utils
    ../../../Bluetooth LE/SimpleBlueNRG_HCI/utils/: gp_timer.c list.c
  group CMSIS
    ../src/: system_stm32l1xx.c
  group EWARM
    ../../../platform/STM32L1XX/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32L1xx/startup/iar/: startup_stm32l1xx_md.s
  group OTA
    ../../../Bluetooth LE/BlueNRG_OTA/src/: btl.c
  group platform/STM32L1XX
    ../../../platform/STM32L1XX/: clock.c hal.c osal.c
  group Platforms_Layers
    ../../../platform/STM32L1XX/Libraries/SDK_Eval_STM32L/src/: SDK_EVAL_Button.c SDK_EVAL_Config.c SDK_EVAL_Led.c SDK_EVAL_Spi_Driver.c
  group STM32L1xx_StdPeriph_Driver
    ../../../platform/STM32L1XX/Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_systick.c stm32l1xx_tim.c stm32l1xx_usart.c
  group STM32L1xx_StdPeriph_Driver/USB-FS-Device_Driver
    ../../../platform/STM32L1XX/Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group User
    ../src/: OTA_ServiceManager_main.c stm32l1xx_it.c
