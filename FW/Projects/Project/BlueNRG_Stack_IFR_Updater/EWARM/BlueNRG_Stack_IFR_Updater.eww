<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\BlueNRG_Stack_IFR_Updater.ewp</path>
  </project>
</workspace>


