# IAR project SensorDemo.ewp, settings and files
configuration LowPower (ARM)
  General.OGChipSelectEditMenu: STM32L151xB ST STM32L151xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; SYSCLK_MSI; LIS_A_INT1_ENABLE; ENABLE_MICRO_SLEEP=1
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Bluetooth LE\SimpleBlueNRG_HCI; ..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes; ..\..\..\platform\STM32L1XX; ..\..\..\platform\STM32L1XX\Libraries; ..\..\..\platform\STM32L1XX\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx; ..\..\..\platform\STM32L1XX\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\platform\STM32L1XX\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\platform\STM32L1XX\Libraries\I2C\inc; ..\..\..\platform\STM32L1XX\Libraries\LIS3DH\inc; ..\..\..\platform\STM32L1XX\Libraries\STLM75\inc; ..\..\..\platform\STM32L1XX\Libraries\HTS221\inc; ..\..\..\platform\STM32L1XX\Libraries\LPS25H\inc; ..\..\..\platform\STM32L1XX\Libraries\SDK_Eval_STM32L\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SensorDemo.hex
  ILINK.IlinkOutputFile: SensorDemo.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration USB (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; SYSCLK_FREQ_HSI_32MHz; LIS_A_INT1_ENABLE; ENABLE_USB; DEBUG; ENABLE_USB_PRINTF
configuration LowPower_LowerApp_OTA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; SYSCLK_MSI; LIS_A_INT1_ENABLE; ST_OTA_BTL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Bluetooth LE\SimpleBlueNRG_HCI; ..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes; ..\..\..\platform\STM32L1XX; ..\..\..\platform\STM32L1XX\Libraries; ..\..\..\platform\STM32L1XX\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx; ..\..\..\platform\STM32L1XX\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\platform\STM32L1XX\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\platform\STM32L1XX\Libraries\I2C\inc; ..\..\..\platform\STM32L1XX\Libraries\LIS3DH\inc; ..\..\..\platform\STM32L1XX\Libraries\STLM75\inc; ..\..\..\platform\STM32L1XX\Libraries\HTS221\inc; ..\..\..\platform\STM32L1XX\Libraries\LPS25H\inc; ..\..\..\platform\STM32L1XX\Libraries\SDK_Eval_STM32L\inc; ..\..\..\Bluetooth LE\BlueNRG_OTA\inc
  OBJCOPY.OOCOutputFile: DFU_OTA_Lower_SensorDemo.hex
  ILINK.IlinkConfigDefines: ST_OTA_BTL=1
configuration LowPower_HigherApp_OTA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; SYSCLK_MSI; LIS_A_INT1_ENABLE; ST_OTA_BTL; HIGHER_APP
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: DFU_OTA_Higher_SensorDemo.bin
  ILINK.IlinkConfigDefines: ST_OTA_BTL=1; HIGHER_APP=1
configuration USB_LowerApp_OTA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; SYSCLK_FREQ_HSI_32MHz; LIS_A_INT1_ENABLE; ENABLE_USB; DEBUG; ENABLE_USB_PRINTF; ST_OTA_BTL
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: USB_LowerApp_OTA_SensorDemo.bin
  ILINK.IlinkConfigDefines: ST_OTA_BTL=1
configuration USB_HigherApp_OTA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; SYSCLK_FREQ_HSI_32MHz; LIS_A_INT1_ENABLE; ENABLE_USB; DEBUG; ENABLE_USB_PRINTF; ST_OTA_BTL; HIGHER_APP
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: USB_HigherApp_OTA_SensorDemo.bin
  ILINK.IlinkConfigDefines: ST_OTA_BTL=1; HIGHER_APP=1
configuration OTA_Basic (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; SYSCLK_MSI; LIS_A_INT1_ENABLE; ST_OTA_BASIC_APPLICATION
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: SensorDemo_OTA_Basic.hex
  ILINK.IlinkConfigDefines: ST_OTA_BASIC_APPLICATION=1
  group blestack/hci
    ../../../Bluetooth LE/SimpleBlueNRG_HCI/hci/: hci.c
  group blestack/hci/controller
    ../../../Bluetooth LE/SimpleBlueNRG_HCI/hci/controller/: bluenrg_hci.c bluenrg_IFR.c bluenrg_utils.c
  group blestack/includes
    ../../../Bluetooth LE/SimpleBlueNRG_HCI/includes/: ble_status.h bluenrg_hci.h bluenrg_hci_internal.h bluenrg_utils.h clock.h compiler.h gap.h gatt_server.h gp_timer.h hal.h hal_types.h hci.h hci_internal.h link_layer.h list.h osal.h sm.h
  group blestack/utils
    ../../../Bluetooth LE/SimpleBlueNRG_HCI/utils/: gp_timer.c list.c
  group CMSIS
    ../src/: system_stm32l1xx.c
  group EWARM
    ../../../platform/STM32L1XX/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32L1xx/startup/iar/: startup_stm32l1xx_md.s
  group Libraries/HTS221/inc
    ../../../platform/STM32L1XX/Libraries/HTS221/inc/: HAL_HTS221.h HTS221.h
  group Libraries/HTS221/src
    ../../../platform/STM32L1XX/Libraries/HTS221/src/: HTS221.c
  group Libraries/I2C/inc
    ../../../platform/STM32L1XX/Libraries/I2C/inc/: i2c.h
  group Libraries/I2C/src
    ../../../platform/STM32L1XX/Libraries/I2C/src/: i2c.c
  group Libraries/LIS3DH/inc
    ../../../platform/STM32L1XX/Libraries/LIS3DH/inc/: HAL_lis3dh.h lis3dh_driver.h
  group Libraries/LIS3DH/src
    ../../../platform/STM32L1XX/Libraries/LIS3DH/src/: lis3dh_driver.c
  group Libraries/LPS25H/inc
    ../../../platform/STM32L1XX/Libraries/LPS25H/inc/: HAL_LPS25H.h LPS25H.h
  group Libraries/LPS25H/src
    ../../../platform/STM32L1XX/Libraries/LPS25H/src/: LPS25H.c
  group Libraries/STLM75/inc
    ../../../platform/STM32L1XX/Libraries/STLM75/inc/: HAL_STLM75.h STLM75.h
  group Libraries/STLM75/src
    ../../../platform/STM32L1XX/Libraries/STLM75/src/: STLM75.c
  group OTA
    ../../../Bluetooth LE/BlueNRG_OTA/src/: btl.c
  group platform/STM32L1XX
    ../../../platform/STM32L1XX/: clock.c hal.c osal.c
  group Platforms_Layers
    ../../../platform/STM32L1XX/Libraries/SDK_Eval_STM32L/src/: SDK_EVAL_Button.c SDK_EVAL_Config.c SDK_EVAL_Io.c SDK_EVAL_Led.c SDK_EVAL_Spi_Driver.c
  group STM32L1xx_StdPeriph_Driver
    ../../../platform/STM32L1XX/Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_systick.c stm32l1xx_tim.c stm32l1xx_usart.c
  group USB-FS-Device_Driver
    ../../../platform/STM32L1XX/Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group User
    ../src/: gatt_db.c hw_config.c low_power.c SensorDemo_main.c SensorDemo_main_OTA.c stm32l1xx_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
    ../inc/: platform_config.h
