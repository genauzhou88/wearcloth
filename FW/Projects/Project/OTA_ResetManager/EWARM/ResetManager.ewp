# IAR project ResetManager.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: STM32L151xB ST STM32L151xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; SYSCLK_FREQ_HSI_32MHz
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\platform\STM32L1XX; ..\..\..\platform\STM32L1XX\Libraries; ..\..\..\platform\STM32L1XX\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx; ..\..\..\platform\STM32L1XX\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\platform\STM32L1XX\Libraries\SDK_Eval_STM32L\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DFU_ResetManager.hex
  ILINK.IlinkOutputFile: ResetManager.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../src/: system_stm32l1xx.c
  group EWARM
    ../../../platform/STM32L1XX/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32L1xx/startup/iar/: startup_stm32l1xx_md.s
  group Platforms_Layers
    ../../../platform/STM32L1XX/Libraries/SDK_Eval_STM32L/src/: SDK_EVAL_Config.c
  group STM32L1xx_StdPeriph_Driver
    ../../../platform/STM32L1XX/Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_syscfg.c stm32l1xx_tim.c
  group User
    ../src/: OTA_ResetManager_main.c
